v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
P 4 2 8440 -40 8440 -40 {}
N 1100 -1320 1200 -1320 {
lab=wl0}
N 1200 -2000 1200 -1320 {
lab=wl0}
N 1100 -1280 1220 -1280 {
lab=wl1}
N 1220 -1780 1220 -1280 {
lab=wl1}
N 1100 -1200 1260 -1200 {
lab=wl3}
N 1260 -1380 1260 -1200 {
lab=wl3}
N 1100 -1160 1260 -1160 {
lab=wl4}
N 1260 -1160 1280 -1160 {
lab=wl4}
N 1280 -1180 1280 -1160 {
lab=wl4}
N 1100 -1120 1260 -1120 {
lab=wl5}
N 1260 -1120 1260 -980 {
lab=wl5}
N 1100 -1080 1240 -1080 {
lab=wl6}
N 1240 -1080 1240 -780 {
lab=wl6}
N 1100 -1050 1210 -1050 {
lab=wl7}
N 1210 -1050 1210 -580 {
lab=wl7}
N 1440 -2000 1440 -1900 {
lab=wl0}
N 2100 -2000 2100 -1900 {
lab=wl0}
N 1440 -1780 1440 -1700 {
lab=wl1}
N 2100 -1780 2100 -1700 {
lab=wl1}
N 1440 -1580 1440 -1500 {
lab=wl2}
N 2100 -1580 2100 -1500 {
lab=wl2}
N 1440 -1380 1440 -1300 {
lab=wl3}
N 2100 -1380 2100 -1300 {
lab=wl3}
N 1440 -1180 1440 -1100 {
lab=wl4}
N 2100 -1180 2100 -1100 {
lab=wl4}
N 1440 -980 1440 -900 {
lab=wl5}
N 2100 -980 2100 -900 {
lab=wl5}
N 1440 -780 1440 -700 {
lab=wl6}
N 2100 -780 2100 -700 {
lab=wl6}
N 1440 -580 1440 -500 {
lab=wl7}
N 2100 -580 2100 -500 {
lab=wl7}
N 1420 -1850 1440 -1850 {
lab=#net1}
N 1560 -1850 1580 -1850 {
lab=#net2}
N 2080 -1850 2100 -1850 {
lab=#net3}
N 2220 -1850 2240 -1850 {
lab=#net4}
N 1560 -1650 1580 -1650 {
lab=#net2}
N 1420 -1650 1440 -1650 {
lab=#net1}
N 2080 -1650 2100 -1650 {
lab=#net3}
N 2220 -1650 2240 -1650 {
lab=#net4}
N 1420 -1450 1440 -1450 {
lab=#net1}
N 1560 -1450 1580 -1450 {
lab=#net2}
N 2080 -1450 2100 -1450 {
lab=#net3}
N 2220 -1450 2240 -1450 {
lab=#net4}
N 1420 -1250 1440 -1250 {
lab=#net1}
N 1560 -1250 1580 -1250 {
lab=#net2}
N 2080 -1250 2100 -1250 {
lab=#net3}
N 2220 -1250 2240 -1250 {
lab=#net4}
N 1420 -1050 1440 -1050 {
lab=#net1}
N 1560 -1050 1580 -1050 {
lab=#net2}
N 2080 -1050 2100 -1050 {
lab=#net3}
N 2220 -1050 2240 -1050 {
lab=#net4}
N 1420 -850 1440 -850 {
lab=#net1}
N 1560 -850 1580 -850 {
lab=#net2}
N 2080 -850 2100 -850 {
lab=#net3}
N 2220 -850 2240 -850 {
lab=#net4}
N 1420 -650 1440 -650 {
lab=#net1}
N 2080 -650 2100 -650 {
lab=#net3}
N 2220 -650 2240 -650 {
lab=#net4}
N 1420 -450 1440 -450 {
lab=#net1}
N 1560 -450 1580 -450 {
lab=#net2}
N 2080 -450 2100 -450 {
lab=#net3}
N 2220 -450 2240 -450 {
lab=#net4}
N 1580 -400 1580 -380 {
lab=#net2}
N 1420 -400 1420 -380 {
lab=#net1}
N 1580 -240 1580 -220 {
lab=#net2}
N 1420 -380 1420 -220 {
lab=#net1}
N 1580 -380 1580 -240 {
lab=#net2}
N 1400 -190 1420 -190 {
lab=vdd}
N 1580 -190 1600 -190 {
lab=vdd}
N 1460 -190 1540 -190 {
lab=YSR}
N 2240 -400 2240 -380 {
lab=#net4}
N 2080 -400 2080 -380 {
lab=#net3}
N 2240 -240 2240 -220 {
lab=#net4}
N 2080 -380 2080 -220 {
lab=#net3}
N 2240 -380 2240 -240 {
lab=#net4}
N 2060 -190 2080 -190 {
lab=vdd}
N 2240 -190 2260 -190 {
lab=vdd}
N 2120 -190 2200 -190 {
lab=YSR}
N 2740 -2000 2740 -1900 {
lab=wl0}
N 2740 -1780 2740 -1700 {
lab=wl1}
N 2740 -1580 2740 -1500 {
lab=wl2}
N 2740 -1380 2740 -1300 {
lab=wl3}
N 2740 -1180 2740 -1100 {
lab=wl4}
N 2740 -980 2740 -900 {
lab=wl5}
N 2740 -780 2740 -700 {
lab=wl6}
N 2740 -580 2740 -500 {
lab=wl7}
N 2720 -1850 2740 -1850 {
lab=#net5}
N 2860 -1850 2880 -1850 {
lab=#net6}
N 2720 -1650 2740 -1650 {
lab=#net5}
N 2860 -1650 2880 -1650 {
lab=#net6}
N 2720 -1450 2740 -1450 {
lab=#net5}
N 2860 -1450 2880 -1450 {
lab=#net6}
N 2720 -1250 2740 -1250 {
lab=#net5}
N 2860 -1250 2880 -1250 {
lab=#net6}
N 2720 -1050 2740 -1050 {
lab=#net5}
N 2860 -1050 2880 -1050 {
lab=#net6}
N 2720 -850 2740 -850 {
lab=#net5}
N 2860 -850 2880 -850 {
lab=#net6}
N 2720 -650 2740 -650 {
lab=#net5}
N 2860 -650 2880 -650 {
lab=#net6}
N 2720 -450 2740 -450 {
lab=#net5}
N 2860 -450 2880 -450 {
lab=#net6}
N 2880 -400 2880 -380 {
lab=#net6}
N 2720 -400 2720 -380 {
lab=#net5}
N 2880 -240 2880 -220 {
lab=#net6}
N 2720 -380 2720 -220 {
lab=#net5}
N 2880 -380 2880 -240 {
lab=#net6}
N 2700 -190 2720 -190 {
lab=vdd}
N 2880 -190 2900 -190 {
lab=vdd}
N 2760 -190 2840 -190 {
lab=YSR}
N 3380 -2000 3380 -1900 {
lab=wl0}
N 3380 -1780 3380 -1700 {
lab=wl1}
N 3380 -1580 3380 -1500 {
lab=wl2}
N 3380 -1380 3380 -1300 {
lab=wl3}
N 3380 -1180 3380 -1100 {
lab=wl4}
N 3380 -980 3380 -900 {
lab=wl5}
N 3380 -780 3380 -700 {
lab=wl6}
N 3380 -580 3380 -500 {
lab=wl7}
N 3360 -1850 3380 -1850 {
lab=#net7}
N 3500 -1850 3520 -1850 {
lab=#net8}
N 3360 -1650 3380 -1650 {
lab=#net7}
N 3500 -1650 3520 -1650 {
lab=#net8}
N 3360 -1450 3380 -1450 {
lab=#net7}
N 3500 -1450 3520 -1450 {
lab=#net8}
N 3360 -1250 3380 -1250 {
lab=#net7}
N 3500 -1250 3520 -1250 {
lab=#net8}
N 3360 -1050 3380 -1050 {
lab=#net7}
N 3500 -1050 3520 -1050 {
lab=#net8}
N 3360 -850 3380 -850 {
lab=#net7}
N 3500 -850 3520 -850 {
lab=#net8}
N 3360 -650 3380 -650 {
lab=#net7}
N 3500 -650 3520 -650 {
lab=#net8}
N 3360 -450 3380 -450 {
lab=#net7}
N 3500 -450 3520 -450 {
lab=#net8}
N 3520 -400 3520 -380 {
lab=#net8}
N 3360 -400 3360 -380 {
lab=#net7}
N 3520 -240 3520 -220 {
lab=#net8}
N 3360 -380 3360 -220 {
lab=#net7}
N 3520 -380 3520 -240 {
lab=#net8}
N 3340 -190 3360 -190 {
lab=vdd}
N 3520 -190 3540 -190 {
lab=vdd}
N 3400 -190 3480 -190 {
lab=YSR}
N 4040 -2000 4040 -1900 {
lab=wl0}
N 4040 -1780 4040 -1700 {
lab=wl1}
N 4040 -1580 4040 -1500 {
lab=wl2}
N 4040 -1380 4040 -1300 {
lab=wl3}
N 4040 -1180 4040 -1100 {
lab=wl4}
N 4040 -980 4040 -900 {
lab=wl5}
N 4040 -780 4040 -700 {
lab=wl6}
N 4040 -580 4040 -500 {
lab=wl7}
N 4020 -1850 4040 -1850 {
lab=#net9}
N 4160 -1850 4180 -1850 {
lab=#net10}
N 4020 -1650 4040 -1650 {
lab=#net9}
N 4160 -1650 4180 -1650 {
lab=#net10}
N 4020 -1450 4040 -1450 {
lab=#net9}
N 4160 -1450 4180 -1450 {
lab=#net10}
N 4020 -1250 4040 -1250 {
lab=#net9}
N 4160 -1250 4180 -1250 {
lab=#net10}
N 4020 -1050 4040 -1050 {
lab=#net9}
N 4160 -1050 4180 -1050 {
lab=#net10}
N 4020 -850 4040 -850 {
lab=#net9}
N 4160 -850 4180 -850 {
lab=#net10}
N 4020 -650 4040 -650 {
lab=#net9}
N 4160 -650 4180 -650 {
lab=#net10}
N 4020 -450 4040 -450 {
lab=#net9}
N 4160 -450 4180 -450 {
lab=#net10}
N 4180 -400 4180 -380 {
lab=#net10}
N 4020 -400 4020 -380 {
lab=#net9}
N 4180 -240 4180 -220 {
lab=#net10}
N 4020 -380 4020 -220 {
lab=#net9}
N 4180 -380 4180 -240 {
lab=#net10}
N 4000 -190 4020 -190 {
lab=vdd}
N 4180 -190 4200 -190 {
lab=vdd}
N 4060 -190 4140 -190 {
lab=YSR}
N 4660 -2000 4660 -1900 {
lab=wl0}
N 4660 -1780 4660 -1700 {
lab=wl1}
N 4660 -1580 4660 -1500 {
lab=wl2}
N 4660 -1380 4660 -1300 {
lab=wl3}
N 4660 -1180 4660 -1100 {
lab=wl4}
N 4660 -980 4660 -900 {
lab=wl5}
N 4660 -780 4660 -700 {
lab=wl6}
N 4660 -580 4660 -500 {
lab=wl7}
N 4640 -1850 4660 -1850 {
lab=#net11}
N 4780 -1850 4800 -1850 {
lab=#net12}
N 4640 -1650 4660 -1650 {
lab=#net11}
N 4780 -1650 4800 -1650 {
lab=#net12}
N 4640 -1450 4660 -1450 {
lab=#net11}
N 4780 -1450 4800 -1450 {
lab=#net12}
N 4640 -1250 4660 -1250 {
lab=#net11}
N 4780 -1250 4800 -1250 {
lab=#net12}
N 4640 -1050 4660 -1050 {
lab=#net11}
N 4780 -1050 4800 -1050 {
lab=#net12}
N 4640 -850 4660 -850 {
lab=#net11}
N 4780 -850 4800 -850 {
lab=#net12}
N 4640 -650 4660 -650 {
lab=#net11}
N 4780 -650 4800 -650 {
lab=#net12}
N 4640 -450 4660 -450 {
lab=#net11}
N 4780 -450 4800 -450 {
lab=#net12}
N 4800 -400 4800 -380 {
lab=#net12}
N 4640 -400 4640 -380 {
lab=#net11}
N 4800 -240 4800 -220 {
lab=#net12}
N 4640 -380 4640 -220 {
lab=#net11}
N 4800 -380 4800 -240 {
lab=#net12}
N 4620 -190 4640 -190 {
lab=vdd}
N 4800 -190 4820 -190 {
lab=vdd}
N 4680 -190 4760 -190 {
lab=YSR}
N 5340 -2000 5340 -1900 {
lab=wl0}
N 5340 -1780 5340 -1700 {
lab=wl1}
N 5340 -1580 5340 -1500 {
lab=wl2}
N 5340 -1380 5340 -1300 {
lab=wl3}
N 5340 -1180 5340 -1100 {
lab=wl4}
N 5340 -980 5340 -900 {
lab=wl5}
N 5340 -780 5340 -700 {
lab=wl6}
N 5340 -580 5340 -500 {
lab=wl7}
N 5320 -1850 5340 -1850 {
lab=#net13}
N 5460 -1850 5480 -1850 {
lab=#net14}
N 5320 -1650 5340 -1650 {
lab=#net13}
N 5460 -1650 5480 -1650 {
lab=#net14}
N 5320 -1450 5340 -1450 {
lab=#net13}
N 5460 -1450 5480 -1450 {
lab=#net14}
N 5320 -1250 5340 -1250 {
lab=#net13}
N 5460 -1250 5480 -1250 {
lab=#net14}
N 5320 -1050 5340 -1050 {
lab=#net13}
N 5460 -1050 5480 -1050 {
lab=#net14}
N 5320 -850 5340 -850 {
lab=#net13}
N 5460 -850 5480 -850 {
lab=#net14}
N 5320 -650 5340 -650 {
lab=#net13}
N 5460 -650 5480 -650 {
lab=#net14}
N 5320 -450 5340 -450 {
lab=#net13}
N 5460 -450 5480 -450 {
lab=#net14}
N 5480 -400 5480 -380 {
lab=#net14}
N 5320 -400 5320 -380 {
lab=#net13}
N 5480 -240 5480 -220 {
lab=#net14}
N 5320 -380 5320 -220 {
lab=#net13}
N 5480 -380 5480 -240 {
lab=#net14}
N 5300 -190 5320 -190 {
lab=vdd}
N 5480 -190 5500 -190 {
lab=vdd}
N 5360 -190 5440 -190 {
lab=YSR}
N 5960 -2000 5960 -1900 {
lab=wl0}
N 5960 -1780 5960 -1700 {
lab=wl1}
N 5960 -1580 5960 -1500 {
lab=wl2}
N 5960 -1380 5960 -1300 {
lab=wl3}
N 5960 -1180 5960 -1100 {
lab=wl4}
N 5960 -980 5960 -900 {
lab=wl5}
N 5960 -780 5960 -700 {
lab=wl6}
N 5960 -580 5960 -500 {
lab=wl7}
N 5940 -1850 5960 -1850 {
lab=#net15}
N 6080 -1850 6100 -1850 {
lab=#net16}
N 5940 -1650 5960 -1650 {
lab=#net15}
N 6080 -1650 6100 -1650 {
lab=#net16}
N 5940 -1450 5960 -1450 {
lab=#net15}
N 6080 -1450 6100 -1450 {
lab=#net16}
N 5940 -1250 5960 -1250 {
lab=#net15}
N 6080 -1250 6100 -1250 {
lab=#net16}
N 5940 -1050 5960 -1050 {
lab=#net15}
N 6080 -1050 6100 -1050 {
lab=#net16}
N 5940 -850 5960 -850 {
lab=#net15}
N 6080 -850 6100 -850 {
lab=#net16}
N 5940 -650 5960 -650 {
lab=#net15}
N 6080 -650 6100 -650 {
lab=#net16}
N 5940 -450 5960 -450 {
lab=#net15}
N 6080 -450 6100 -450 {
lab=#net16}
N 5920 -190 5940 -190 {
lab=vdd}
N 6100 -190 6120 -190 {
lab=vdd}
N 5980 -190 6060 -190 {
lab=YSR}
N 1200 -2000 5960 -2000 {
lab=wl0}
N 1220 -1780 5960 -1780 {
lab=wl1}
N 1260 -1380 5960 -1380 {
lab=wl3}
N 1280 -1180 5960 -1180 {
lab=wl4}
N 1260 -980 5960 -980 {
lab=wl5}
N 1240 -780 5960 -780 {
lab=wl6}
N 1210 -580 5960 -580 {
lab=wl7}
N 3390 -1950 3420 -1950 {
lab=GND}
N 4050 -1950 4080 -1950 {
lab=GND}
N 4670 -1950 4700 -1950 {
lab=GND}
N 5350 -1950 5380 -1950 {
lab=GND}
N 5970 -1950 6000 -1950 {
lab=GND}
N 1450 -1750 1480 -1750 {
lab=GND}
N 2110 -1750 2140 -1750 {
lab=GND}
N 2750 -1750 2780 -1750 {
lab=GND}
N 3390 -1750 3420 -1750 {
lab=GND}
N 4050 -1750 4080 -1750 {
lab=GND}
N 4670 -1750 4700 -1750 {
lab=GND}
N 4670 -1550 4700 -1550 {
lab=GND}
N 5350 -1750 5380 -1750 {
lab=GND}
N 5350 -1550 5380 -1550 {
lab=GND}
N 4050 -1550 4080 -1550 {
lab=GND}
N 3390 -1550 3420 -1550 {
lab=GND}
N 2750 -1550 2780 -1550 {
lab=GND}
N 2110 -1550 2140 -1550 {
lab=GND}
N 1450 -1550 1480 -1550 {
lab=GND}
N 1450 -1350 1480 -1350 {
lab=GND}
N 2110 -1350 2140 -1350 {
lab=GND}
N 2750 -1350 2780 -1350 {
lab=GND}
N 2110 -1150 2140 -1150 {
lab=GND}
N 2750 -1150 2780 -1150 {
lab=GND}
N 3390 -1150 3420 -1150 {
lab=GND}
N 3390 -1350 3420 -1350 {
lab=GND}
N 4050 -1350 4080 -1350 {
lab=GND}
N 4050 -1150 4080 -1150 {
lab=GND}
N 4670 -1150 4700 -1150 {
lab=GND}
N 4670 -1350 4700 -1350 {
lab=GND}
N 4670 -950 4700 -950 {
lab=GND}
N 5350 -950 5380 -950 {
lab=GND}
N 5350 -1150 5380 -1150 {
lab=GND}
N 5350 -1350 5380 -1350 {
lab=GND}
N 5970 -1350 6000 -1350 {
lab=GND}
N 5970 -1550 6000 -1550 {
lab=GND}
N 5970 -1750 6000 -1750 {
lab=GND}
N 5970 -1150 6000 -1150 {
lab=GND}
N 5970 -950 6000 -950 {
lab=GND}
N 4050 -950 4080 -950 {
lab=GND}
N 3390 -950 3420 -950 {
lab=GND}
N 2750 -950 2780 -950 {
lab=GND}
N 2110 -950 2140 -950 {
lab=GND}
N 1450 -950 1480 -950 {
lab=GND}
N 5970 -750 6000 -750 {
lab=GND}
N 5970 -550 6000 -550 {
lab=GND}
N 5350 -550 5380 -550 {
lab=GND}
N 5350 -750 5380 -750 {
lab=GND}
N 4670 -550 4700 -550 {
lab=GND}
N 4670 -750 4700 -750 {
lab=GND}
N 4050 -550 4080 -550 {
lab=GND}
N 4050 -750 4080 -750 {
lab=GND}
N 3390 -550 3420 -550 {
lab=GND}
N 3390 -750 3420 -750 {
lab=GND}
N 2750 -550 2780 -550 {
lab=GND}
N 2750 -750 2780 -750 {
lab=GND}
N 2110 -550 2140 -550 {
lab=GND}
N 2110 -750 2140 -750 {
lab=GND}
N 1450 -550 1480 -550 {
lab=GND}
N 1450 -750 1480 -750 {
lab=GND}
N 1450 -1150 1480 -1150 {
lab=GND}
N 1090 880 1150 880 {
lab=GND}
N 1560 -650 1580 -650 {
lab=#net2}
N 1050 -1360 1090 -1360 {
lab=GND}
N 1100 -1240 1240 -1240 {
lab=wl2}
N 1240 -1580 1240 -1240 {
lab=wl2}
N 1240 -1580 5960 -1580 {
lab=wl2}
N 1560 820 1560 1390 {
lab=Douta}
N 6080 1320 6080 1390 {
lab=Douta}
N 2860 960 2860 1390 {
lab=Douta}
N 3500 1030 3500 1390 {
lab=Douta}
N 4160 1100 4160 1390 {
lab=Douta}
N 4780 1180 4780 1390 {
lab=Douta}
N 5460 1250 5460 1390 {
lab=Douta}
N 2220 890 2220 1390 {
lab=Douta}
N 1560 790 1600 790 {
lab=GND}
N 2220 860 2260 860 {
lab=GND}
N 2860 930 2900 930 {
lab=GND}
N 3500 1000 3540 1000 {
lab=GND}
N 4160 1070 4200 1070 {
lab=GND}
N 4780 1150 4820 1150 {
lab=GND}
N 5460 1220 5500 1220 {
lab=GND}
N 6080 1290 6120 1290 {
lab=GND}
N 2450 1720 2490 1720 {
lab=GND}
N 3090 1780 3130 1780 {
lab=GND}
N 3730 1840 3770 1840 {
lab=GND}
N 4390 1900 4430 1900 {
lab=GND}
N 5010 1980 5050 1980 {
lab=GND}
N 5690 2040 5730 2040 {
lab=GND}
N 6310 2100 6350 2100 {
lab=GND}
N 6770 1790 6830 1790 {
lab=GND}
N 1870 1660 6440 1660 {
lab=w0}
N 2530 1720 6420 1720 {
lab=w1}
N 3170 1780 6400 1780 {
lab=w2}
N 3810 1840 6380 1840 {
lab=w3}
N 1830 1690 1830 2220 {
lab=Din}
N 1830 2220 6350 2220 {
lab=Din}
N 6350 2130 6350 2220 {
lab=Din}
N 5730 2070 5730 2220 {
lab=Din}
N 5050 2010 5050 2220 {
lab=Din}
N 4430 1930 4430 2220 {
lab=Din}
N 3770 1870 3770 2220 {
lab=Din}
N 3130 1810 3130 2220 {
lab=Din}
N 2490 1750 2490 2220 {
lab=Din}
N 6100 -400 6100 -220 {
lab=#net16}
N 5940 -400 5940 -220 {
lab=#net15}
N 1910 -190 1930 -190 {
lab=GND}
N 1730 -190 1750 -190 {
lab=GND}
N 1790 -190 1870 -190 {
lab=YSW}
N 2570 -190 2590 -190 {
lab=GND}
N 2390 -190 2410 -190 {
lab=GND}
N 2450 -190 2530 -190 {
lab=YSW}
N 3210 -190 3230 -190 {
lab=GND}
N 3030 -190 3050 -190 {
lab=GND}
N 3090 -190 3170 -190 {
lab=YSW}
N 3850 -190 3870 -190 {
lab=GND}
N 3670 -190 3690 -190 {
lab=GND}
N 3730 -190 3810 -190 {
lab=YSW}
N 4510 -190 4530 -190 {
lab=GND}
N 4330 -190 4350 -190 {
lab=GND}
N 4390 -190 4470 -190 {
lab=YSW}
N 5130 -190 5150 -190 {
lab=GND}
N 4950 -190 4970 -190 {
lab=GND}
N 5010 -190 5090 -190 {
lab=YSW}
N 5810 -190 5830 -190 {
lab=GND}
N 5630 -190 5650 -190 {
lab=GND}
N 5690 -190 5770 -190 {
lab=YSW}
N 6430 -190 6450 -190 {
lab=GND}
N 6250 -190 6270 -190 {
lab=GND}
N 6310 -190 6390 -190 {
lab=YSW}
N 1750 -260 1750 -220 {
lab=#net1}
N 1420 -260 1750 -260 {
lab=#net1}
N 1910 -320 1910 -220 {
lab=#net2}
N 1580 -320 1910 -320 {
lab=#net2}
N 2410 -260 2410 -220 {
lab=#net3}
N 2080 -260 2410 -260 {
lab=#net3}
N 2570 -320 2570 -220 {
lab=#net4}
N 2240 -320 2570 -320 {
lab=#net4}
N 3050 -260 3050 -220 {
lab=#net5}
N 2720 -260 3050 -260 {
lab=#net5}
N 3210 -320 3210 -220 {
lab=#net6}
N 2880 -320 3210 -320 {
lab=#net6}
N 3690 -260 3690 -220 {
lab=#net7}
N 3360 -260 3690 -260 {
lab=#net7}
N 3850 -320 3850 -220 {
lab=#net8}
N 3520 -320 3850 -320 {
lab=#net8}
N 4350 -260 4350 -220 {
lab=#net9}
N 4020 -260 4350 -260 {
lab=#net9}
N 4510 -320 4510 -220 {
lab=#net10}
N 4180 -320 4510 -320 {
lab=#net10}
N 4970 -260 4970 -220 {
lab=#net11}
N 4640 -260 4970 -260 {
lab=#net11}
N 5130 -320 5130 -220 {
lab=#net12}
N 4800 -320 5130 -320 {
lab=#net12}
N 5650 -260 5650 -220 {
lab=#net13}
N 5320 -260 5650 -260 {
lab=#net13}
N 5810 -320 5810 -220 {
lab=#net14}
N 5480 -320 5810 -320 {
lab=#net14}
N 6270 -260 6270 -220 {
lab=#net15}
N 5940 -260 6270 -260 {
lab=#net15}
N 6430 -320 6430 -220 {
lab=#net16}
N 6100 -320 6430 -320 {
lab=#net16}
N 1570 40 1580 40 {
lab=#net17}
N 1420 40 1430 40 {
lab=#net18}
N 1430 40 1470 40 {
lab=#net18}
N 1530 40 1570 40 {
lab=#net17}
N 1530 30 1530 40 {
lab=#net17}
N 1470 30 1470 40 {
lab=#net18}
N 1430 -90 1430 -30 {
lab=pch}
N 2230 40 2240 40 {
lab=#net19}
N 2080 40 2090 40 {
lab=#net20}
N 2090 40 2130 40 {
lab=#net20}
N 2190 40 2230 40 {
lab=#net19}
N 2190 30 2190 40 {
lab=#net19}
N 2130 30 2130 40 {
lab=#net20}
N 2090 -90 2090 -30 {
lab=pch}
N 2870 40 2880 40 {
lab=#net21}
N 2720 40 2730 40 {
lab=#net22}
N 2730 40 2770 40 {
lab=#net22}
N 2830 40 2870 40 {
lab=#net21}
N 2830 30 2830 40 {
lab=#net21}
N 2770 30 2770 40 {
lab=#net22}
N 2730 -90 2730 -30 {
lab=pch}
N 3510 40 3520 40 {
lab=#net23}
N 3360 40 3370 40 {
lab=#net24}
N 3370 40 3410 40 {
lab=#net24}
N 3470 40 3510 40 {
lab=#net23}
N 3470 30 3470 40 {
lab=#net23}
N 3410 30 3410 40 {
lab=#net24}
N 3370 -90 3370 -30 {
lab=pch}
N 4170 40 4180 40 {
lab=#net25}
N 4020 40 4030 40 {
lab=#net26}
N 4030 40 4070 40 {
lab=#net26}
N 4130 40 4170 40 {
lab=#net25}
N 4130 30 4130 40 {
lab=#net25}
N 4070 30 4070 40 {
lab=#net26}
N 4030 -90 4030 -30 {
lab=pch}
N 4790 40 4800 40 {
lab=#net27}
N 4640 40 4650 40 {
lab=#net28}
N 4650 40 4690 40 {
lab=#net28}
N 4750 40 4790 40 {
lab=#net27}
N 4750 30 4750 40 {
lab=#net27}
N 4690 30 4690 40 {
lab=#net28}
N 4650 -90 4650 -30 {
lab=pch}
N 5470 40 5480 40 {
lab=#net29}
N 5320 40 5330 40 {
lab=#net30}
N 5330 40 5370 40 {
lab=#net30}
N 5430 40 5470 40 {
lab=#net29}
N 5430 30 5430 40 {
lab=#net29}
N 5370 30 5370 40 {
lab=#net30}
N 5330 -90 5330 -30 {
lab=pch}
N 6090 40 6100 40 {
lab=#net31}
N 5940 40 5950 40 {
lab=#net32}
N 5950 40 5990 40 {
lab=#net32}
N 6050 40 6090 40 {
lab=#net31}
N 6050 30 6050 40 {
lab=#net31}
N 5990 30 5990 40 {
lab=#net32}
N 5950 -90 5950 -30 {
lab=pch}
N 1420 -1850 1420 -400 {
lab=#net1}
N 1580 -1850 1580 -400 {
lab=#net2}
N 2080 -1850 2080 -400 {
lab=#net3}
N 2240 -1850 2240 -400 {
lab=#net4}
N 2720 -1850 2720 -400 {
lab=#net5}
N 2880 -1850 2880 -400 {
lab=#net6}
N 3360 -1850 3360 -400 {
lab=#net7}
N 3520 -1850 3520 -400 {
lab=#net8}
N 4020 -1850 4020 -400 {
lab=#net9}
N 4180 -1850 4180 -400 {
lab=#net10}
N 4640 -1850 4640 -400 {
lab=#net11}
N 4800 -1850 4800 -400 {
lab=#net12}
N 5320 -1850 5320 -400 {
lab=#net13}
N 5480 -1850 5480 -400 {
lab=#net14}
N 5940 -1850 5940 -400 {
lab=#net15}
N 6100 -1850 6100 -400 {
lab=#net16}
N 1530 100 1580 100 {
lab=#net17}
N 1420 100 1470 100 {
lab=#net18}
N 1400 200 1430 200 {
lab=SEb}
N 2190 100 2240 100 {
lab=#net19}
N 2080 100 2130 100 {
lab=#net20}
N 2060 200 2090 200 {
lab=SEb}
N 2830 100 2880 100 {
lab=#net21}
N 2720 100 2770 100 {
lab=#net22}
N 2700 200 2730 200 {
lab=SEb}
N 3470 100 3520 100 {
lab=#net23}
N 3360 100 3410 100 {
lab=#net24}
N 3340 200 3370 200 {
lab=SEb}
N 4130 100 4180 100 {
lab=#net25}
N 4020 100 4070 100 {
lab=#net26}
N 4000 200 4030 200 {
lab=SEb}
N 4750 100 4800 100 {
lab=#net27}
N 4640 100 4690 100 {
lab=#net28}
N 4620 200 4650 200 {
lab=SEb}
N 5430 100 5480 100 {
lab=#net29}
N 5320 100 5370 100 {
lab=#net30}
N 5300 200 5330 200 {
lab=SEb}
N 6050 100 6100 100 {
lab=#net31}
N 5940 100 5990 100 {
lab=#net32}
N 5920 200 5950 200 {
lab=SEb}
N 1520 480 1580 480 {
lab=#net17}
N 1420 480 1480 480 {
lab=#net18}
N 2180 480 2240 480 {
lab=#net19}
N 2080 480 2140 480 {
lab=#net20}
N 2820 480 2880 480 {
lab=#net21}
N 2720 480 2780 480 {
lab=#net22}
N 3460 480 3520 480 {
lab=#net23}
N 3360 480 3420 480 {
lab=#net24}
N 4120 480 4180 480 {
lab=#net25}
N 4020 480 4080 480 {
lab=#net26}
N 4740 480 4800 480 {
lab=#net27}
N 4640 480 4700 480 {
lab=#net28}
N 5420 480 5480 480 {
lab=#net29}
N 5320 480 5380 480 {
lab=#net30}
N 6040 480 6100 480 {
lab=#net31}
N 5940 480 6000 480 {
lab=#net32}
N 1750 -70 1810 -70 {
lab=#net33}
N 1750 -160 1750 -70 {
lab=#net33}
N 1850 -70 1910 -70 {
lab=#net34}
N 1910 -160 1910 -70 {
lab=#net34}
N 2410 -70 2470 -70 {
lab=#net35}
N 2410 -160 2410 -70 {
lab=#net35}
N 2510 -70 2570 -70 {
lab=#net36}
N 2570 -160 2570 -70 {
lab=#net36}
N 3050 -70 3110 -70 {
lab=#net37}
N 3050 -160 3050 -70 {
lab=#net37}
N 3150 -70 3210 -70 {
lab=#net38}
N 3210 -160 3210 -70 {
lab=#net38}
N 3690 -70 3750 -70 {
lab=#net39}
N 3690 -160 3690 -70 {
lab=#net39}
N 3790 -70 3850 -70 {
lab=#net40}
N 3850 -160 3850 -70 {
lab=#net40}
N 4350 -70 4410 -70 {
lab=#net41}
N 4350 -160 4350 -70 {
lab=#net41}
N 4450 -70 4510 -70 {
lab=#net42}
N 4510 -160 4510 -70 {
lab=#net42}
N 4970 -70 5030 -70 {
lab=#net43}
N 4970 -160 4970 -70 {
lab=#net43}
N 5070 -70 5130 -70 {
lab=#net44}
N 5130 -160 5130 -70 {
lab=#net44}
N 5650 -70 5710 -70 {
lab=#net45}
N 5650 -160 5650 -70 {
lab=#net45}
N 5750 -70 5810 -70 {
lab=#net46}
N 5810 -160 5810 -70 {
lab=#net46}
N 6270 -70 6330 -70 {
lab=#net47}
N 6270 -160 6270 -70 {
lab=#net47}
N 6370 -70 6430 -70 {
lab=#net48}
N 6430 -160 6430 -70 {
lab=#net48}
N 1560 1390 6080 1390 {
lab=Douta}
N 1140 920 1480 920 {
lab=r0}
N 1480 790 1480 920 {
lab=r0}
N 1480 790 1520 790 {
lab=r0}
N 1140 960 2140 960 {
lab=r1}
N 2140 860 2140 960 {
lab=r1}
N 2140 860 2180 860 {
lab=r1}
N 1140 1000 2780 1000 {
lab=r2}
N 2780 930 2780 1000 {
lab=r2}
N 2780 930 2820 930 {
lab=r2}
N 1140 1040 3400 1040 {
lab=r3}
N 3400 1000 3400 1040 {
lab=r3}
N 3400 1000 3460 1000 {
lab=r3}
N 1140 1080 4080 1080 {
lab=r4}
N 4080 1070 4080 1080 {
lab=r4}
N 4080 1070 4120 1070 {
lab=r4}
N 1140 1120 4700 1120 {
lab=r5}
N 4700 1120 4700 1150 {
lab=r5}
N 4700 1150 4740 1150 {
lab=r5}
N 1140 1160 4660 1160 {
lab=r6}
N 4660 1160 4660 1220 {
lab=r6}
N 4660 1220 5420 1220 {
lab=r6}
N 1140 1190 4620 1190 {
lab=r7}
N 4620 1190 4620 1290 {
lab=r7}
N 4620 1290 6040 1290 {
lab=r7}
N 6390 2100 6780 2100 {
lab=w7}
N 6440 1660 6440 1830 {
lab=w0}
N 6440 1830 6780 1830 {
lab=w0}
N 6420 1720 6420 1870 {
lab=w1}
N 6420 1870 6780 1870 {
lab=w1}
N 6400 1780 6400 1910 {
lab=w2}
N 6400 1910 6780 1910 {
lab=w2}
N 6380 1840 6380 1950 {
lab=w3}
N 6380 1950 6780 1950 {
lab=w3}
N 4470 1900 6360 1900 {
lab=w4}
N 6360 1900 6360 1990 {
lab=w4}
N 6360 1990 6780 1990 {
lab=w4}
N 5090 1980 6340 1980 {
lab=w5}
N 6340 1980 6340 2030 {
lab=w5}
N 6340 2030 6780 2030 {
lab=w5}
N 5770 2040 6320 2040 {
lab=w6}
N 6320 2040 6320 2050 {
lab=w6}
N 6320 2050 6320 2060 {
lab=w6}
N 6320 2060 6660 2060 {
lab=w6}
N 6660 2060 6660 2070 {
lab=w6}
N 6660 2070 6780 2070 {
lab=w6}
N 1430 -90 6490 -90 {
lab=pch}
N 1400 200 1400 230 {
lab=SEb}
N 1400 230 6510 230 {
lab=SEb}
N 5920 200 5920 230 {
lab=SEb}
N 5300 200 5300 230 {
lab=SEb}
N 4620 200 4620 230 {
lab=SEb}
N 3340 200 3340 230 {
lab=SEb}
N 2700 200 2700 230 {
lab=SEb}
N 2060 200 2060 230 {
lab=SEb}
N 4000 200 4000 230 {
lab=SEb}
N 1400 170 1430 170 {
lab=SE}
N 1400 80 1400 170 {
lab=SE}
N 1400 80 6520 80 {
lab=SE}
N 6680 220 6680 240 {
lab=SE}
N 6680 220 6740 220 {
lab=SE}
N 1500 -190 1500 -130 {
lab=YSR}
N 1500 -130 6520 -130 {
lab=YSR}
N 6490 -90 6520 -90 {
lab=pch}
N 1830 -230 1830 -190 {
lab=YSW}
N 2160 -190 2160 -130 {
lab=YSR}
N 2800 -190 2800 -130 {
lab=YSR}
N 3440 -190 3440 -130 {
lab=YSR}
N 4100 -190 4100 -130 {
lab=YSR}
N 4720 -190 4720 -130 {
lab=YSR}
N 5400 -190 5400 -130 {
lab=YSR}
N 6020 -190 6020 -130 {
lab=YSR}
N 1830 -230 6520 -230 {
lab=YSW}
N 2490 -230 2490 -190 {
lab=YSW}
N 3130 -230 3130 -190 {
lab=YSW}
N 3770 -230 3770 -190 {
lab=YSW}
N 4430 -230 4430 -190 {
lab=YSW}
N 5050 -230 5050 -190 {
lab=YSW}
N 5730 -230 5730 -190 {
lab=YSW}
N 6350 -230 6350 -190 {
lab=YSW}
N 2060 170 2090 170 {
lab=SE}
N 2060 80 2060 170 {
lab=SE}
N 2700 170 2730 170 {
lab=SE}
N 2700 80 2700 170 {
lab=SE}
N 3340 170 3370 170 {
lab=SE}
N 3340 80 3340 170 {
lab=SE}
N 3990 170 4030 170 {
lab=SE}
N 3990 80 3990 170 {
lab=SE}
N 4610 170 4650 170 {
lab=SE}
N 4610 80 4610 170 {
lab=SE}
N 5290 170 5330 170 {
lab=SE}
N 5290 80 5290 170 {
lab=SE}
N 5910 170 5950 170 {
lab=SE}
N 5910 80 5910 170 {
lab=SE}
N 1790 1660 1830 1660 {
lab=GND}
N 1450 -1950 1480 -1950 {
lab=GND}
N 2110 -1950 2140 -1950 {
lab=GND}
N 2750 -1950 2780 -1950 {
lab=GND}
N 3930 2560 3930 2590 {
lab=#net49}
N 4070 2560 4070 2590 {
lab=Dout}
N 4070 2580 4160 2580 {
lab=Dout}
N 4070 2620 4100 2620 {
lab=GND}
N 4100 2620 4100 2690 {
lab=GND}
N 3930 2690 4100 2690 {
lab=GND}
N 3930 2650 3930 2690 {
lab=GND}
N 3930 2620 3960 2620 {
lab=GND}
N 3960 2620 3960 2690 {
lab=GND}
N 4070 2650 4070 2690 {
lab=GND}
N 3930 2530 3960 2530 {
lab=vdd}
N 3960 2470 3960 2530 {
lab=vdd}
N 3930 2470 3960 2470 {
lab=vdd}
N 3930 2470 3930 2500 {
lab=vdd}
N 3960 2470 4100 2470 {
lab=vdd}
N 4100 2470 4100 2530 {
lab=vdd}
N 4070 2530 4100 2530 {
lab=vdd}
N 4070 2470 4070 2500 {
lab=vdd}
N 4000 2530 4030 2530 {
lab=#net49}
N 4000 2530 4000 2620 {
lab=#net49}
N 4000 2620 4030 2620 {
lab=#net49}
N 3860 2620 3890 2620 {
lab=Douta}
N 3860 2530 3860 2620 {
lab=Douta}
N 3860 2530 3890 2530 {
lab=Douta}
N 3930 2580 4000 2580 {
lab=#net49}
N 3830 2580 3860 2580 {
lab=Douta}
N 3820 1390 3820 2580 {
lab=Douta}
N 3820 2580 3830 2580 {
lab=Douta}
N 1580 -160 1580 280 {
lab=#net17}
N 1420 400 1420 480 {
lab=#net18}
N 1580 400 1580 480 {
lab=#net17}
N 2240 -160 2240 280 {
lab=#net19}
N 2080 400 2080 480 {
lab=#net20}
N 2240 400 2240 480 {
lab=#net19}
N 2880 -160 2880 280 {
lab=#net21}
N 2720 400 2720 480 {
lab=#net22}
N 2880 400 2880 480 {
lab=#net21}
N 3520 -160 3520 280 {
lab=#net23}
N 3360 400 3360 480 {
lab=#net24}
N 3520 400 3520 480 {
lab=#net23}
N 4180 -160 4180 280 {
lab=#net25}
N 4020 400 4020 480 {
lab=#net26}
N 4180 400 4180 480 {
lab=#net25}
N 4800 -160 4800 280 {
lab=#net27}
N 4640 400 4640 480 {
lab=#net28}
N 4800 400 4800 480 {
lab=#net27}
N 5480 -160 5480 280 {
lab=#net29}
N 5320 400 5320 480 {
lab=#net30}
N 5480 400 5480 480 {
lab=#net29}
N 6100 -160 6100 280 {
lab=#net31}
N 5940 400 5940 480 {
lab=#net32}
N 6100 400 6100 480 {
lab=#net31}
N 1420 -160 1420 280 {
lab=#net18}
N 2080 -160 2080 280 {
lab=#net20}
N 2720 -160 2720 280 {
lab=#net22}
N 3360 -160 3360 280 {
lab=#net24}
N 4640 -160 4640 280 {
lab=#net28}
N 4020 -160 4020 280 {
lab=#net26}
N 5320 -160 5320 280 {
lab=#net30}
N 5940 -160 5940 280 {
lab=#net32}
N 1830 50 1830 420 {
lab=#net50}
N 2490 50 2490 420 {
lab=#net51}
N 3130 50 3130 420 {
lab=#net52}
N 3770 50 3770 420 {
lab=#net53}
N 4430 50 4430 420 {
lab=#net54}
N 5050 50 5050 420 {
lab=#net55}
N 5730 50 5730 420 {
lab=#net56}
N 6350 50 6350 420 {
lab=#net57}
N 1560 540 1560 760 {
lab=Dout0}
N 2220 540 2220 830 {
lab=Dout1}
N 2860 540 2860 900 {
lab=Dout2}
N 3500 540 3500 970 {
lab=Dout3}
N 4160 540 4160 1040 {
lab=Dout4}
N 4780 540 4780 1120 {
lab=Dout5}
N 5460 540 5460 1190 {
lab=Dout6}
N 6080 540 6080 1260 {
lab=Dout7}
N 1830 540 1830 1630 {
lab=#net58}
N 2490 540 2490 1690 {
lab=#net59}
N 3130 540 3130 1750 {
lab=#net60}
N 3770 540 3770 1810 {
lab=#net61}
N 4430 540 4430 1870 {
lab=#net62}
N 5050 540 5050 1950 {
lab=#net63}
N 5730 540 5730 2010 {
lab=#net64}
N 6350 540 6350 2070 {
lab=#net65}
N 1420 280 1420 400 {
lab=#net18}
N 1580 280 1580 400 {
lab=#net17}
N 2080 280 2080 400 {
lab=#net20}
N 2240 280 2240 400 {
lab=#net19}
N 2720 280 2720 400 {
lab=#net22}
N 2880 280 2880 400 {
lab=#net21}
N 3360 280 3360 400 {
lab=#net24}
N 3520 280 3520 400 {
lab=#net23}
N 4020 280 4020 400 {
lab=#net26}
N 4180 280 4180 400 {
lab=#net25}
N 4640 280 4640 400 {
lab=#net28}
N 4800 280 4800 400 {
lab=#net27}
N 5320 280 5320 400 {
lab=#net30}
N 5480 280 5480 400 {
lab=#net29}
N 5940 280 5940 400 {
lab=#net32}
N 6100 280 6100 400 {
lab=#net31}
N 3820 2680 3860 2680 {
lab=GND}
N 3820 2580 3820 2650 {
lab=Douta}
C {sram_6t_cell.sym} 1420 -1690 0 0 {name=x2}
C {sram_6t_cell.sym} 2080 -1690 0 0 {name=x5}
C {sram_6t_cell.sym} 1420 -1490 0 0 {name=x6}
C {sram_6t_cell.sym} 2080 -1490 0 0 {name=x7}
C {sram_6t_cell.sym} 1420 -1290 0 0 {name=x8}
C {sram_6t_cell.sym} 2080 -1290 0 0 {name=x9}
C {sram_6t_cell.sym} 1420 -1090 0 0 {name=x10}
C {sram_6t_cell.sym} 2080 -1090 0 0 {name=x11}
C {sram_6t_cell.sym} 1420 -890 0 0 {name=x12}
C {sram_6t_cell.sym} 2080 -890 0 0 {name=x13}
C {sram_6t_cell.sym} 1420 -690 0 0 {name=x14}
C {sram_6t_cell.sym} 2080 -690 0 0 {name=x15}
C {sram_6t_cell.sym} 1420 -490 0 0 {name=x16}
C {sram_6t_cell.sym} 2080 -490 0 0 {name=x17}
C {sram_6t_cell.sym} 1420 -290 0 0 {name=x18}
C {sram_6t_cell.sym} 2080 -290 0 0 {name=x19}
C {devices/lab_pin.sym} 1520 -1950 1 0 {name=p2 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -1950 1 0 {name=p4 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -1750 1 0 {name=p6 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -1750 1 0 {name=p8 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -1550 1 0 {name=p10 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -1550 1 0 {name=p12 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -1350 1 0 {name=p14 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -1350 1 0 {name=p16 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -1150 1 0 {name=p18 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -1150 1 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -950 1 0 {name=p22 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -950 1 0 {name=p24 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -750 1 0 {name=p26 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -750 1 0 {name=p28 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1520 -550 1 0 {name=p30 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2180 -550 1 0 {name=p32 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1030 -1360 1 0 {name=p35 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1070 880 3 1 {name=p53 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 1560 -190 0 0 {name=M1
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1440 -190 2 0 {name=M2
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1400 -190 0 0 {name=p63 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1600 -190 2 0 {name=p64 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2220 -190 0 0 {name=M5
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2100 -190 2 0 {name=M6
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2060 -190 0 0 {name=p75 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2260 -190 2 0 {name=p76 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 2720 -1690 0 0 {name=x37}
C {sram_6t_cell.sym} 2720 -1490 0 0 {name=x38}
C {sram_6t_cell.sym} 2720 -1290 0 0 {name=x39}
C {sram_6t_cell.sym} 2720 -1090 0 0 {name=x40}
C {sram_6t_cell.sym} 2720 -890 0 0 {name=x41}
C {sram_6t_cell.sym} 2720 -690 0 0 {name=x42}
C {sram_6t_cell.sym} 2720 -490 0 0 {name=x43}
C {sram_6t_cell.sym} 2720 -290 0 0 {name=x44}
C {devices/lab_pin.sym} 2820 -1950 1 0 {name=p90 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -1750 1 0 {name=p92 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -1550 1 0 {name=p94 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -1350 1 0 {name=p96 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -1150 1 0 {name=p98 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -950 1 0 {name=p100 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -750 1 0 {name=p102 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2820 -550 1 0 {name=p104 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2860 -190 0 0 {name=M11
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2740 -190 2 0 {name=M12
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2700 -190 0 0 {name=p109 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2900 -190 2 0 {name=p110 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 3360 -1690 0 0 {name=x51}
C {sram_6t_cell.sym} 3360 -1490 0 0 {name=x52}
C {sram_6t_cell.sym} 3360 -1290 0 0 {name=x53}
C {sram_6t_cell.sym} 3360 -1090 0 0 {name=x54}
C {sram_6t_cell.sym} 3360 -890 0 0 {name=x55}
C {sram_6t_cell.sym} 3360 -690 0 0 {name=x56}
C {sram_6t_cell.sym} 3360 -490 0 0 {name=x57}
C {sram_6t_cell.sym} 3360 -290 0 0 {name=x58}
C {devices/lab_pin.sym} 3460 -1950 1 0 {name=p124 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -1750 1 0 {name=p126 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -1550 1 0 {name=p128 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -1350 1 0 {name=p130 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -1150 1 0 {name=p132 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -950 1 0 {name=p134 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -750 1 0 {name=p136 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3460 -550 1 0 {name=p138 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 3500 -190 0 0 {name=M17
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3380 -190 2 0 {name=M18
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3340 -190 0 0 {name=p143 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 3540 -190 2 0 {name=p144 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 4020 -1690 0 0 {name=x65}
C {sram_6t_cell.sym} 4020 -1490 0 0 {name=x66}
C {sram_6t_cell.sym} 4020 -1290 0 0 {name=x67}
C {sram_6t_cell.sym} 4020 -1090 0 0 {name=x68}
C {sram_6t_cell.sym} 4020 -890 0 0 {name=x69}
C {sram_6t_cell.sym} 4020 -690 0 0 {name=x70}
C {sram_6t_cell.sym} 4020 -490 0 0 {name=x71}
C {sram_6t_cell.sym} 4020 -290 0 0 {name=x72}
C {devices/lab_pin.sym} 4120 -1950 1 0 {name=p158 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -1750 1 0 {name=p160 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -1550 1 0 {name=p162 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -1350 1 0 {name=p164 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -1150 1 0 {name=p166 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -950 1 0 {name=p168 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -750 1 0 {name=p170 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4120 -550 1 0 {name=p172 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 4160 -190 0 0 {name=M21
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4040 -190 2 0 {name=M22
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4000 -190 0 0 {name=p177 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4200 -190 2 0 {name=p178 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 4640 -1690 0 0 {name=x79}
C {sram_6t_cell.sym} 4640 -1490 0 0 {name=x80}
C {sram_6t_cell.sym} 4640 -1290 0 0 {name=x81}
C {sram_6t_cell.sym} 4640 -1090 0 0 {name=x82}
C {sram_6t_cell.sym} 4640 -890 0 0 {name=x83}
C {sram_6t_cell.sym} 4640 -690 0 0 {name=x84}
C {sram_6t_cell.sym} 4640 -490 0 0 {name=x85}
C {sram_6t_cell.sym} 4640 -290 0 0 {name=x86}
C {devices/lab_pin.sym} 4740 -1950 1 0 {name=p192 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -1750 1 0 {name=p194 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -1550 1 0 {name=p196 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -1350 1 0 {name=p198 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -1150 1 0 {name=p200 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -950 1 0 {name=p202 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -750 1 0 {name=p204 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4740 -550 1 0 {name=p206 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 4780 -190 0 0 {name=M25
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4660 -190 2 0 {name=M26
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4620 -190 0 0 {name=p211 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 4820 -190 2 0 {name=p212 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 5320 -1690 0 0 {name=x93}
C {sram_6t_cell.sym} 5320 -1490 0 0 {name=x94}
C {sram_6t_cell.sym} 5320 -1290 0 0 {name=x95}
C {sram_6t_cell.sym} 5320 -1090 0 0 {name=x96}
C {sram_6t_cell.sym} 5320 -890 0 0 {name=x97}
C {sram_6t_cell.sym} 5320 -690 0 0 {name=x98}
C {sram_6t_cell.sym} 5320 -490 0 0 {name=x99}
C {sram_6t_cell.sym} 5320 -290 0 0 {name=x100}
C {devices/lab_pin.sym} 5420 -1950 1 0 {name=p226 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -1750 1 0 {name=p228 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -1550 1 0 {name=p230 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -1350 1 0 {name=p232 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -1150 1 0 {name=p234 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -950 1 0 {name=p236 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -750 1 0 {name=p238 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5420 -550 1 0 {name=p240 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 5460 -190 0 0 {name=M29
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5340 -190 2 0 {name=M30
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5300 -190 0 0 {name=p245 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 5500 -190 2 0 {name=p246 sig_type=std_logic lab=vdd}
C {sram_6t_cell.sym} 5940 -1690 0 0 {name=x107}
C {sram_6t_cell.sym} 5940 -1490 0 0 {name=x108}
C {sram_6t_cell.sym} 5940 -1290 0 0 {name=x109}
C {sram_6t_cell.sym} 5940 -1090 0 0 {name=x110}
C {sram_6t_cell.sym} 5940 -890 0 0 {name=x111}
C {sram_6t_cell.sym} 5940 -690 0 0 {name=x112}
C {sram_6t_cell.sym} 5940 -490 0 0 {name=x113}
C {sram_6t_cell.sym} 5940 -290 0 0 {name=x114}
C {devices/lab_pin.sym} 6040 -1950 1 0 {name=p260 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -1750 1 0 {name=p262 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -1550 1 0 {name=p264 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -1350 1 0 {name=p266 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -1150 1 0 {name=p268 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -950 1 0 {name=p270 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -750 1 0 {name=p272 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6040 -550 1 0 {name=p274 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 6080 -190 0 0 {name=M33
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5960 -190 2 0 {name=M34
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5920 -190 0 0 {name=p279 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 6120 -190 2 0 {name=p280 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 980 -1140 2 1 {name=p324 sig_type=std_logic lab=s2}
C {devices/lab_pin.sym} 980 -1180 2 1 {name=p325 sig_type=std_logic lab=s1}
C {devices/lab_pin.sym} 980 -1220 2 1 {name=p326 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 1040 -1000 2 1 {name=p327 sig_type=std_logic lab=En}
C {devices/lab_pin.sym} 4090 2220 1 1 {name=p36 sig_type=std_logic lab=Din}
C {devices/code_shown.sym} 6660 -1360 0 0 {name=SRAM_Test_Bench only_toplevel=false value=".lib /usr/local/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.tran .02ns 160ns
.save all   
.end"}
C {devices/gnd.sym} 1450 -1950 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} 2110 -1950 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} 2750 -1950 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} 3390 -1950 0 0 {name=l22 lab=GND}
C {devices/gnd.sym} 4050 -1950 0 0 {name=l23 lab=GND}
C {devices/gnd.sym} 4670 -1950 0 0 {name=l24 lab=GND}
C {devices/gnd.sym} 5350 -1950 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} 5970 -1950 0 0 {name=l26 lab=GND}
C {devices/gnd.sym} 1450 -1750 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 2110 -1750 0 0 {name=l28 lab=GND}
C {devices/gnd.sym} 2750 -1750 0 0 {name=l29 lab=GND}
C {devices/gnd.sym} 3390 -1750 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} 4050 -1750 0 0 {name=l31 lab=GND}
C {devices/gnd.sym} 4670 -1750 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} 4670 -1550 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 5350 -1750 0 0 {name=l34 lab=GND}
C {devices/gnd.sym} 5350 -1550 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 4050 -1550 0 0 {name=l36 lab=GND}
C {devices/gnd.sym} 3390 -1550 0 0 {name=l37 lab=GND}
C {devices/gnd.sym} 2750 -1550 0 0 {name=l38 lab=GND}
C {devices/gnd.sym} 2110 -1550 0 0 {name=l39 lab=GND}
C {devices/gnd.sym} 1450 -1550 0 0 {name=l40 lab=GND}
C {devices/gnd.sym} 1450 -1350 0 0 {name=l41 lab=GND}
C {devices/gnd.sym} 2110 -1350 0 0 {name=l42 lab=GND}
C {devices/gnd.sym} 2750 -1350 0 0 {name=l43 lab=GND}
C {devices/gnd.sym} 2110 -1150 0 0 {name=l44 lab=GND}
C {devices/gnd.sym} 2750 -1150 0 0 {name=l45 lab=GND}
C {devices/gnd.sym} 3390 -1150 0 0 {name=l46 lab=GND}
C {devices/gnd.sym} 3390 -1350 0 0 {name=l47 lab=GND}
C {devices/gnd.sym} 4050 -1350 0 0 {name=l48 lab=GND}
C {devices/gnd.sym} 4050 -1150 0 0 {name=l49 lab=GND}
C {devices/gnd.sym} 4670 -1150 0 0 {name=l50 lab=GND}
C {devices/gnd.sym} 4670 -1350 0 0 {name=l51 lab=GND}
C {devices/gnd.sym} 4670 -950 0 0 {name=l52 lab=GND}
C {devices/gnd.sym} 5350 -950 0 0 {name=l53 lab=GND}
C {devices/gnd.sym} 5350 -1150 0 0 {name=l54 lab=GND}
C {devices/gnd.sym} 5350 -1350 0 0 {name=l55 lab=GND}
C {devices/gnd.sym} 5970 -1350 0 0 {name=l56 lab=GND}
C {devices/gnd.sym} 5970 -1550 0 0 {name=l57 lab=GND}
C {devices/gnd.sym} 5970 -1750 0 0 {name=l58 lab=GND}
C {devices/gnd.sym} 5970 -1150 0 0 {name=l59 lab=GND}
C {devices/gnd.sym} 5970 -950 0 0 {name=l60 lab=GND}
C {devices/gnd.sym} 4050 -950 0 0 {name=l61 lab=GND}
C {devices/gnd.sym} 3390 -950 0 0 {name=l62 lab=GND}
C {devices/gnd.sym} 2750 -950 0 0 {name=l63 lab=GND}
C {devices/gnd.sym} 2110 -950 0 0 {name=l64 lab=GND}
C {devices/gnd.sym} 1450 -950 0 0 {name=l65 lab=GND}
C {devices/gnd.sym} 5970 -750 0 0 {name=l66 lab=GND}
C {devices/gnd.sym} 5970 -550 0 0 {name=l67 lab=GND}
C {devices/gnd.sym} 5350 -550 0 0 {name=l68 lab=GND}
C {devices/gnd.sym} 5350 -750 0 0 {name=l69 lab=GND}
C {devices/gnd.sym} 4670 -550 0 0 {name=l70 lab=GND}
C {devices/gnd.sym} 4670 -750 0 0 {name=l71 lab=GND}
C {devices/gnd.sym} 4050 -550 0 0 {name=l72 lab=GND}
C {devices/gnd.sym} 4050 -750 0 0 {name=l73 lab=GND}
C {devices/gnd.sym} 3390 -550 0 0 {name=l74 lab=GND}
C {devices/gnd.sym} 3390 -750 0 0 {name=l75 lab=GND}
C {devices/gnd.sym} 2750 -550 0 0 {name=l76 lab=GND}
C {devices/gnd.sym} 2750 -750 0 0 {name=l77 lab=GND}
C {devices/gnd.sym} 2110 -550 0 0 {name=l78 lab=GND}
C {devices/gnd.sym} 2110 -750 0 0 {name=l79 lab=GND}
C {devices/gnd.sym} 1450 -550 0 0 {name=l80 lab=GND}
C {devices/gnd.sym} 1450 -750 0 0 {name=l81 lab=GND}
C {devices/gnd.sym} 1450 -1150 0 0 {name=l82 lab=GND}
C {devices/gnd.sym} 1150 880 0 1 {name=l124 lab=GND}
C {devices/gnd.sym} 1090 -1360 0 0 {name=l131 lab=GND}
C {decoder_3to8.sym} 940 -900 0 0 {name=x1}
C {devices/lab_pin.sym} 1560 -1900 2 0 {name=p3 sig_type=std_logic lab=Q00}
C {devices/lab_pin.sym} 2220 -1900 2 0 {name=p7 sig_type=std_logic lab=Q01}
C {devices/lab_pin.sym} 2860 -1900 2 0 {name=p9 sig_type=std_logic lab=Q02}
C {devices/lab_pin.sym} 3500 -1900 2 0 {name=p11 sig_type=std_logic lab=Q03}
C {devices/lab_pin.sym} 4160 -1900 2 0 {name=p13 sig_type=std_logic lab=Q04}
C {devices/lab_pin.sym} 4780 -1900 2 0 {name=p15 sig_type=std_logic lab=Q05}
C {devices/lab_pin.sym} 5460 -1900 2 0 {name=p17 sig_type=std_logic lab=Q06}
C {devices/lab_pin.sym} 6080 -1900 2 0 {name=p19 sig_type=std_logic lab=Q07}
C {devices/lab_pin.sym} 6840 2150 1 1 {name=p25 sig_type=std_logic lab=Enwr}
C {devices/lab_pin.sym} 1080 1240 1 1 {name=p27 sig_type=std_logic lab=Enre}
C {devices/lab_pin.sym} 1020 1100 0 0 {name=p34 sig_type=std_logic lab=e2}
C {devices/lab_pin.sym} 1020 1060 0 0 {name=p37 sig_type=std_logic lab=e1}
C {devices/lab_pin.sym} 1020 1020 0 0 {name=p42 sig_type=std_logic lab=e0}
C {decoder_3to8.sym} 980 1340 0 0 {name=x3}
C {sky130_fd_pr/nfet_01v8.sym} 1540 790 0 0 {name=M9
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2200 860 0 0 {name=M10
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2840 930 0 0 {name=M13
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3480 1000 0 0 {name=M14
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4140 1070 0 0 {name=M37
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4760 1150 0 0 {name=M38
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5440 1220 0 0 {name=M39
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6060 1290 0 0 {name=M40
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1600 790 0 1 {name=l125 lab=GND}
C {devices/gnd.sym} 2260 860 0 1 {name=l126 lab=GND}
C {devices/gnd.sym} 2900 930 0 1 {name=l127 lab=GND}
C {devices/gnd.sym} 3540 1000 0 1 {name=l128 lab=GND}
C {devices/gnd.sym} 4200 1070 0 1 {name=l129 lab=GND}
C {devices/gnd.sym} 4820 1150 0 1 {name=l130 lab=GND}
C {devices/gnd.sym} 5500 1220 0 1 {name=l133 lab=GND}
C {devices/gnd.sym} 6120 1290 0 1 {name=l134 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1850 1660 0 1 {name=M41
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2510 1720 0 1 {name=M42
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2450 1720 0 0 {name=l136 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3150 1780 0 1 {name=M43
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3090 1780 0 0 {name=l137 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3790 1840 0 1 {name=M44
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3730 1840 0 0 {name=l138 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4450 1900 0 1 {name=M45
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4390 1900 0 0 {name=l139 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5070 1980 0 1 {name=M46
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5010 1980 0 0 {name=l140 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5750 2040 0 1 {name=M47
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5690 2040 0 0 {name=l141 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6370 2100 0 1 {name=M48
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6310 2100 0 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} 6850 1790 1 0 {name=p91 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 6770 1790 0 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} 6900 2010 0 1 {name=p95 sig_type=std_logic lab=e2}
C {devices/lab_pin.sym} 6900 1970 0 1 {name=p97 sig_type=std_logic lab=e1}
C {devices/lab_pin.sym} 6900 1930 0 1 {name=p99 sig_type=std_logic lab=e0}
C {decoder_3to8.sym} 6940 2250 0 1 {name=x4}
C {sky130_fd_pr/nfet_01v8.sym} 1890 -190 0 0 {name=M3
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1770 -190 2 0 {name=M19
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1730 -190 0 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1930 -190 0 0 {name=l9 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2550 -190 0 0 {name=M4
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2430 -190 2 0 {name=M7
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2390 -190 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} 2590 -190 0 0 {name=l83 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3190 -190 0 0 {name=M8
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3070 -190 2 0 {name=M15
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3030 -190 0 0 {name=l84 lab=GND}
C {devices/gnd.sym} 3230 -190 0 0 {name=l85 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3830 -190 0 0 {name=M16
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3710 -190 2 0 {name=M20
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3670 -190 0 0 {name=l86 lab=GND}
C {devices/gnd.sym} 3870 -190 0 0 {name=l87 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4490 -190 0 0 {name=M23
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4370 -190 2 0 {name=M24
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4330 -190 0 0 {name=l88 lab=GND}
C {devices/gnd.sym} 4530 -190 0 0 {name=l89 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5110 -190 0 0 {name=M27
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4990 -190 2 0 {name=M28
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4950 -190 0 0 {name=l90 lab=GND}
C {devices/gnd.sym} 5150 -190 0 0 {name=l91 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5790 -190 0 0 {name=M31
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5670 -190 2 0 {name=M32
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5630 -190 0 0 {name=l92 lab=GND}
C {devices/gnd.sym} 5830 -190 0 0 {name=l93 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6410 -190 0 0 {name=M35
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -190 2 0 {name=M36
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6250 -190 0 0 {name=l94 lab=GND}
C {devices/gnd.sym} 6450 -190 0 0 {name=l95 lab=GND}
C {precharge.sym} 1330 -360 2 1 {name=x23}
C {devices/lab_pin.sym} 1570 -30 2 0 {name=p31 sig_type=std_logic lab=vddp}
C {precharge.sym} 1990 -360 2 1 {name=x21}
C {devices/lab_pin.sym} 2230 -30 2 0 {name=p44 sig_type=std_logic lab=vddp}
C {precharge.sym} 2630 -360 2 1 {name=x22}
C {devices/lab_pin.sym} 2870 -30 2 0 {name=p46 sig_type=std_logic lab=vddp}
C {precharge.sym} 3270 -360 2 1 {name=x24}
C {devices/lab_pin.sym} 3510 -30 2 0 {name=p51 sig_type=std_logic lab=vddp}
C {precharge.sym} 3930 -360 2 1 {name=x25}
C {devices/lab_pin.sym} 4170 -30 2 0 {name=p52 sig_type=std_logic lab=vddp}
C {precharge.sym} 4550 -360 2 1 {name=x28}
C {devices/lab_pin.sym} 4790 -30 2 0 {name=p56 sig_type=std_logic lab=vddp}
C {precharge.sym} 5230 -360 2 1 {name=x29}
C {devices/lab_pin.sym} 5470 -30 2 0 {name=p58 sig_type=std_logic lab=vddp}
C {precharge.sym} 5850 -360 2 1 {name=x30}
C {devices/lab_pin.sym} 6090 -30 2 0 {name=p60 sig_type=std_logic lab=vddp}
C {devices/lab_pin.sym} 1570 190 2 0 {name=p67 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 1570 210 0 0 {name=l114 lab=GND}
C {sense_amp.sym} 1350 380 0 0 {name=x26}
C {devices/lab_pin.sym} 2230 190 2 0 {name=p1 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 2230 210 0 0 {name=l96 lab=GND}
C {sense_amp.sym} 2010 380 0 0 {name=x27}
C {devices/lab_pin.sym} 2870 190 2 0 {name=p38 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 2870 210 0 0 {name=l97 lab=GND}
C {sense_amp.sym} 2650 380 0 0 {name=x31}
C {devices/lab_pin.sym} 3510 190 2 0 {name=p39 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 3510 210 0 0 {name=l98 lab=GND}
C {sense_amp.sym} 3290 380 0 0 {name=x32}
C {devices/lab_pin.sym} 4170 190 2 0 {name=p43 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4170 210 0 0 {name=l99 lab=GND}
C {sense_amp.sym} 3950 380 0 0 {name=x33}
C {devices/lab_pin.sym} 4790 190 2 0 {name=p45 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4790 210 0 0 {name=l100 lab=GND}
C {sense_amp.sym} 4570 380 0 0 {name=x34}
C {devices/lab_pin.sym} 5470 190 2 0 {name=p47 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 5470 210 0 0 {name=l101 lab=GND}
C {sense_amp.sym} 5250 380 0 0 {name=x35}
C {devices/lab_pin.sym} 6090 190 2 0 {name=p54 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 6090 210 0 0 {name=l102 lab=GND}
C {sense_amp.sym} 5870 380 0 0 {name=x36}
C {nand_latch.sym} 1420 760 0 0 {name=x45}
C {devices/lab_pin.sym} 1440 540 0 0 {name=p65 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 1440 560 0 0 {name=l115 lab=GND}
C {nand_latch.sym} 2080 760 0 0 {name=x46}
C {devices/lab_pin.sym} 2100 540 0 0 {name=p66 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 2100 560 0 0 {name=l103 lab=GND}
C {nand_latch.sym} 2720 760 0 0 {name=x47}
C {devices/lab_pin.sym} 2740 540 0 0 {name=p68 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 2740 560 0 0 {name=l104 lab=GND}
C {nand_latch.sym} 3360 760 0 0 {name=x48}
C {devices/lab_pin.sym} 3380 540 0 0 {name=p69 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 3380 560 0 0 {name=l105 lab=GND}
C {nand_latch.sym} 4020 760 0 0 {name=x49}
C {devices/lab_pin.sym} 4040 540 0 0 {name=p70 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4040 560 0 0 {name=l106 lab=GND}
C {nand_latch.sym} 4640 760 0 0 {name=x50}
C {devices/lab_pin.sym} 4660 540 0 0 {name=p71 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4660 560 0 0 {name=l107 lab=GND}
C {nand_latch.sym} 5320 760 0 0 {name=x59}
C {devices/lab_pin.sym} 5340 540 0 0 {name=p72 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 5340 560 0 0 {name=l108 lab=GND}
C {nand_latch.sym} 5940 760 0 0 {name=x60}
C {devices/lab_pin.sym} 5960 540 0 0 {name=p73 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 5960 560 0 0 {name=l109 lab=GND}
C {write_amp.sym} 1770 190 0 0 {name=x61}
C {devices/gnd.sym} 1890 10 0 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} 1890 -10 2 0 {name=p74 sig_type=std_logic lab=vdd}
C {write_amp.sym} 2430 190 0 0 {name=x62}
C {devices/gnd.sym} 2550 10 0 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 2550 -10 2 0 {name=p77 sig_type=std_logic lab=vdd}
C {write_amp.sym} 3070 190 0 0 {name=x63}
C {devices/gnd.sym} 3190 10 0 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} 3190 -10 2 0 {name=p78 sig_type=std_logic lab=vdd}
C {write_amp.sym} 3710 190 0 0 {name=x64}
C {devices/gnd.sym} 3830 10 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} 3830 -10 2 0 {name=p79 sig_type=std_logic lab=vdd}
C {write_amp.sym} 4370 190 0 0 {name=x73}
C {devices/gnd.sym} 4490 10 0 0 {name=l116 lab=GND}
C {devices/lab_pin.sym} 4490 -10 2 0 {name=p80 sig_type=std_logic lab=vdd}
C {write_amp.sym} 4990 190 0 0 {name=x74}
C {devices/gnd.sym} 5110 10 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} 5110 -10 2 0 {name=p81 sig_type=std_logic lab=vdd}
C {write_amp.sym} 5670 190 0 0 {name=x75}
C {devices/gnd.sym} 5790 10 0 0 {name=l118 lab=GND}
C {devices/lab_pin.sym} 5790 -10 2 0 {name=p82 sig_type=std_logic lab=vdd}
C {write_amp.sym} 6290 190 0 0 {name=x76}
C {devices/gnd.sym} 6410 10 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} 6410 -10 2 0 {name=p83 sig_type=std_logic lab=vdd}
C {buffer.sym} 2030 660 3 0 {name=x77}
C {devices/lab_pin.sym} 1780 490 0 0 {name=p84 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 1880 490 0 0 {name=l120 lab=GND}
C {buffer.sym} 2690 660 3 0 {name=x78}
C {devices/lab_pin.sym} 2440 490 0 0 {name=p85 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 2540 490 0 0 {name=l121 lab=GND}
C {buffer.sym} 3330 660 3 0 {name=x87}
C {devices/lab_pin.sym} 3080 490 0 0 {name=p86 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 3180 490 0 0 {name=l122 lab=GND}
C {buffer.sym} 3970 660 3 0 {name=x88}
C {devices/lab_pin.sym} 3720 490 0 0 {name=p87 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 3820 490 0 0 {name=l123 lab=GND}
C {buffer.sym} 4630 660 3 0 {name=x89}
C {devices/lab_pin.sym} 4380 490 0 0 {name=p88 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4480 490 0 0 {name=l144 lab=GND}
C {buffer.sym} 5250 660 3 0 {name=x90}
C {devices/lab_pin.sym} 5000 490 0 0 {name=p89 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 5100 490 0 0 {name=l145 lab=GND}
C {buffer.sym} 5930 660 3 0 {name=x91}
C {devices/lab_pin.sym} 5680 490 0 0 {name=p93 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 5780 490 0 0 {name=l146 lab=GND}
C {buffer.sym} 6550 660 3 0 {name=x92}
C {devices/lab_pin.sym} 6300 490 0 0 {name=p101 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 6400 490 0 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} 6520 -90 2 0 {name=p103 sig_type=std_logic lab=pch}
C {devices/lab_pin.sym} 6510 230 2 0 {name=p105 sig_type=std_logic lab=SEb}
C {devices/lab_pin.sym} 6520 80 2 0 {name=p106 sig_type=std_logic lab=SE}
C {devices/vsource.sym} 6670 -1150 0 0 {name=Vdd1 value=1.8 savecurrent=false
lab=vdd}
C {devices/lab_pin.sym} 6670 -1180 1 0 {name=p107 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 6670 -1120 0 0 {name=l135 lab=GND}
C {devices/vsource.sym} 6790 -1150 0 0 {name=Vddp1 value=1.8 savecurrent=false
lab=vdd}
C {devices/lab_pin.sym} 6790 -1180 1 0 {name=p108 sig_type=std_logic lab=vddp}
C {devices/gnd.sym} 6790 -1120 0 0 {name=l148 lab=GND}
C {devices/lab_pin.sym} 6680 -870 3 1 {name=p111 sig_type=std_logic lab=En}
C {devices/vsource.sym} 6680 -840 0 0 {name=VEN1 value="PULSE(0 1.8 0 .1n .1n 2n 10n 20)" savecurrent=false
lab=vdd}
C {devices/gnd.sym} 6680 -810 0 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} 7010 -60 3 1 {name=p112 sig_type=std_logic lab=Enre}
C {devices/vsource.sym} 6680 -670 0 0 {name=Vs0 value="PULSE(1.8 0 0 .1n .1n 210n 220n 1)" savecurrent=false}
C {devices/vsource.sym} 6960 -670 0 0 {name=Vs1 value="PULSE(1.8 0 0 .4n .4n 210n 220n 1)" savecurrent=false}
C {devices/gnd.sym} 6680 -640 0 0 {name=l150 lab=GND}
C {devices/gnd.sym} 6960 -640 0 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} 6680 -700 1 0 {name=p113 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 6960 -700 1 0 {name=p114 sig_type=std_logic lab=s1}
C {devices/vsource.sym} 6680 -510 0 0 {name=Ve0 value="PULSE(0 1.8 80n .1n .1n 80n 100n 4)" savecurrent=false}
C {devices/vsource.sym} 6960 -510 0 0 {name=Ve1 value="PULSE(0 1.8 40n .1n .1n 40n 80n 4)" savecurrent=false}
C {devices/gnd.sym} 6680 -480 0 0 {name=l152 lab=GND}
C {devices/gnd.sym} 6960 -480 0 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} 6680 -540 1 0 {name=p115 sig_type=std_logic lab=e0}
C {devices/lab_pin.sym} 6960 -540 1 0 {name=p116 sig_type=std_logic lab=e1}
C {devices/vsource.sym} 7460 -670 0 0 {name=VYSW value="PULSE(0 1.8 0 .1n .1n 2n 20n 12)" savecurrent=false}
C {devices/gnd.sym} 7460 -640 0 0 {name=l154 lab=GND}
C {devices/lab_pin.sym} 6680 20 1 0 {name=p117 sig_type=std_logic lab=YSR}
C {devices/lab_pin.sym} 7460 -700 1 0 {name=p118 sig_type=std_logic lab=YSW}
C {devices/lab_pin.sym} 6680 220 1 0 {name=p119 sig_type=std_logic lab=SE}
C {devices/lab_pin.sym} 6670 -1020 3 1 {name=p120 sig_type=std_logic lab=Din}
C {devices/vsource.sym} 6670 -990 0 0 {name=VDin value="PULSE(0 1.8 0 .1n .1n 10n 20n 12)" savecurrent=false}
C {devices/gnd.sym} 6670 -960 0 0 {name=l155 lab=GND}
C {devices/vsource.sym} 6680 50 0 0 {name=VYSR value="PULSE(1.8 0 3n .1n .1n 2n 20n 24)" savecurrent=false}
C {devices/gnd.sym} 6680 80 0 0 {name=l156 lab=GND}
C {devices/vsource.sym} 6680 270 0 0 {name=VSE value="PULSE(0 1.8 10n .1n .1n 2n 20n 10)" savecurrent=false}
C {devices/gnd.sym} 6680 300 0 0 {name=Vdelay1 lab=GND}
C {devices/vsource.sym} 7010 -30 0 0 {name=Venre value="PULSE(0 1.8 10n .1n .1n 10n 20n 12)" savecurrent=false
lab=vdd}
C {devices/gnd.sym} 7010 0 0 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} 6940 -870 3 1 {name=p121 sig_type=std_logic lab=Enwr}
C {devices/vsource.sym} 6940 -840 0 0 {name=Venwr1 value="PULSE(0 1.8 0 .1n .1n 2n 20n 12)" savecurrent=false
lab=vdd}
C {devices/gnd.sym} 6940 -810 0 0 {name=l158 lab=GND}
C {devices/lab_pin.sym} 6680 -150 1 0 {name=p122 sig_type=std_logic lab=pch}
C {devices/vsource.sym} 6680 -120 0 0 {name=Vphi value="PULSE(1.8 0 2n .1n .1n 1n 20n 12)" savecurrent=false
lab=vdd}
C {devices/gnd.sym} 6680 -90 0 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} 6900 220 2 0 {name=p123 sig_type=std_logic lab=SEb}
C {inverter.sym} 6640 660 0 0 {name=x101}
C {devices/gnd.sym} 6790 270 0 0 {name=Vdelay2 lab=GND}
C {devices/lab_pin.sym} 6790 170 1 0 {name=p125 sig_type=std_logic lab=vdd}
C {devices/vsource.sym} 7200 -670 0 0 {name=Vs2 value="PULSE(1.8 0 0 .4n .4n 210n 220n 1)" savecurrent=false}
C {devices/gnd.sym} 7200 -640 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 7200 -700 1 0 {name=p21 sig_type=std_logic lab=s2}
C {devices/vsource.sym} 7200 -510 0 0 {name=Ve2 value="PULSE(0 1.8 20n .1n .1n 20n 40n 4)" savecurrent=false}
C {devices/gnd.sym} 7200 -480 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 7200 -540 1 0 {name=p23 sig_type=std_logic lab=e2}
C {devices/lab_pin.sym} 6520 -130 2 0 {name=p29 sig_type=std_logic lab=YSR}
C {devices/lab_pin.sym} 6520 -230 2 0 {name=p33 sig_type=std_logic lab=YSW}
C {devices/lab_pin.sym} 1560 -1700 2 0 {name=p40 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 2220 -1700 2 0 {name=p41 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 2860 -1700 2 0 {name=p48 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 3500 -1700 2 0 {name=p49 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 4160 -1700 2 0 {name=p50 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 4780 -1700 2 0 {name=p55 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 5460 -1700 2 0 {name=p57 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} 6080 -1700 2 0 {name=p59 sig_type=std_logic lab=Q17}
C {devices/lab_pin.sym} 1560 -1500 2 0 {name=p61 sig_type=std_logic lab=Q20}
C {devices/lab_pin.sym} 2220 -1500 2 0 {name=p62 sig_type=std_logic lab=Q21}
C {devices/lab_pin.sym} 2860 -1500 2 0 {name=p127 sig_type=std_logic lab=Q22}
C {devices/lab_pin.sym} 3500 -1500 2 0 {name=p129 sig_type=std_logic lab=Q23}
C {devices/lab_pin.sym} 4160 -1500 2 0 {name=p131 sig_type=std_logic lab=Q24}
C {devices/lab_pin.sym} 4780 -1500 2 0 {name=p133 sig_type=std_logic lab=Q25}
C {devices/lab_pin.sym} 5460 -1500 2 0 {name=p135 sig_type=std_logic lab=Q26}
C {devices/lab_pin.sym} 6080 -1500 2 0 {name=p137 sig_type=std_logic lab=Q27}
C {devices/lab_pin.sym} 1560 -1300 2 0 {name=p139 sig_type=std_logic lab=Q30}
C {devices/lab_pin.sym} 2220 -1300 2 0 {name=p140 sig_type=std_logic lab=Q31}
C {devices/lab_pin.sym} 2860 -1300 2 0 {name=p141 sig_type=std_logic lab=Q32}
C {devices/lab_pin.sym} 3500 -1300 2 0 {name=p142 sig_type=std_logic lab=Q33}
C {devices/lab_pin.sym} 4160 -1300 2 0 {name=p145 sig_type=std_logic lab=Q34}
C {devices/lab_pin.sym} 4780 -1300 2 0 {name=p146 sig_type=std_logic lab=Q35}
C {devices/lab_pin.sym} 5460 -1300 2 0 {name=p147 sig_type=std_logic lab=Q36}
C {devices/lab_pin.sym} 6080 -1300 2 0 {name=p148 sig_type=std_logic lab=Q37}
C {devices/lab_pin.sym} 1560 -1100 2 0 {name=p149 sig_type=std_logic lab=Q40}
C {devices/lab_pin.sym} 2220 -1100 2 0 {name=p150 sig_type=std_logic lab=Q41}
C {devices/lab_pin.sym} 2860 -1100 2 0 {name=p151 sig_type=std_logic lab=Q42}
C {devices/lab_pin.sym} 3500 -1100 2 0 {name=p152 sig_type=std_logic lab=Q43}
C {devices/lab_pin.sym} 4160 -1100 2 0 {name=p153 sig_type=std_logic lab=Q44}
C {devices/lab_pin.sym} 4780 -1100 2 0 {name=p154 sig_type=std_logic lab=Q45}
C {devices/lab_pin.sym} 5460 -1100 2 0 {name=p155 sig_type=std_logic lab=Q46}
C {devices/lab_pin.sym} 6080 -1100 2 0 {name=p156 sig_type=std_logic lab=Q47}
C {devices/lab_pin.sym} 1560 -900 2 0 {name=p157 sig_type=std_logic lab=Q50}
C {devices/lab_pin.sym} 2220 -900 2 0 {name=p159 sig_type=std_logic lab=Q51}
C {devices/lab_pin.sym} 2860 -900 2 0 {name=p161 sig_type=std_logic lab=Q52}
C {devices/lab_pin.sym} 3500 -900 2 0 {name=p163 sig_type=std_logic lab=Q53}
C {devices/lab_pin.sym} 4160 -900 2 0 {name=p165 sig_type=std_logic lab=Q54}
C {devices/lab_pin.sym} 4780 -900 2 0 {name=p167 sig_type=std_logic lab=Q55}
C {devices/lab_pin.sym} 5460 -900 2 0 {name=p169 sig_type=std_logic lab=Q56}
C {devices/lab_pin.sym} 6080 -900 2 0 {name=p171 sig_type=std_logic lab=Q57}
C {devices/lab_pin.sym} 1560 -700 2 0 {name=p173 sig_type=std_logic lab=Q60}
C {devices/lab_pin.sym} 2220 -700 2 0 {name=p174 sig_type=std_logic lab=Q61}
C {devices/lab_pin.sym} 2860 -700 2 0 {name=p175 sig_type=std_logic lab=Q62}
C {devices/lab_pin.sym} 3500 -700 2 0 {name=p176 sig_type=std_logic lab=Q63}
C {devices/lab_pin.sym} 4160 -700 2 0 {name=p179 sig_type=std_logic lab=Q64}
C {devices/lab_pin.sym} 4780 -700 2 0 {name=p180 sig_type=std_logic lab=Q65}
C {devices/lab_pin.sym} 5460 -700 2 0 {name=p181 sig_type=std_logic lab=Q66}
C {devices/lab_pin.sym} 6080 -700 2 0 {name=p182 sig_type=std_logic lab=Q67}
C {devices/lab_pin.sym} 1560 -500 2 0 {name=p183 sig_type=std_logic lab=Q70}
C {devices/lab_pin.sym} 2220 -500 2 0 {name=p184 sig_type=std_logic lab=Q71}
C {devices/lab_pin.sym} 2860 -500 2 0 {name=p185 sig_type=std_logic lab=Q72}
C {devices/lab_pin.sym} 3500 -500 2 0 {name=p186 sig_type=std_logic lab=Q73}
C {devices/lab_pin.sym} 4780 -500 2 0 {name=p187 sig_type=std_logic lab=Q75}
C {devices/lab_pin.sym} 4160 -500 2 0 {name=p188 sig_type=std_logic lab=Q74}
C {devices/lab_pin.sym} 5460 -500 2 0 {name=p189 sig_type=std_logic lab=Q76}
C {devices/lab_pin.sym} 6080 -500 2 0 {name=p190 sig_type=std_logic lab=Q77}
C {devices/lab_pin.sym} 1560 -1880 2 0 {name=p191 sig_type=std_logic lab=Q00b}
C {devices/lab_pin.sym} 2220 -1880 2 0 {name=p193 sig_type=std_logic lab=Q01b}
C {devices/lab_pin.sym} 2860 -1880 2 0 {name=p195 sig_type=std_logic lab=Q02b}
C {devices/lab_pin.sym} 3500 -1880 2 0 {name=p197 sig_type=std_logic lab=Q03b}
C {devices/lab_pin.sym} 4160 -1880 2 0 {name=p199 sig_type=std_logic lab=Q04b}
C {devices/lab_pin.sym} 4780 -1880 2 0 {name=p201 sig_type=std_logic lab=Q05b}
C {devices/lab_pin.sym} 5460 -1880 2 0 {name=p203 sig_type=std_logic lab=Q06b}
C {devices/lab_pin.sym} 6080 -1880 2 0 {name=p205 sig_type=std_logic lab=Q07b}
C {devices/lab_pin.sym} 6080 -1680 2 0 {name=p207 sig_type=std_logic lab=Q17b}
C {devices/lab_pin.sym} 6080 -1480 2 0 {name=p208 sig_type=std_logic lab=Q27b}
C {devices/lab_pin.sym} 6080 -1280 2 0 {name=p209 sig_type=std_logic lab=Q37b}
C {devices/lab_pin.sym} 6080 -1080 2 0 {name=p210 sig_type=std_logic lab=Q47b}
C {devices/lab_pin.sym} 6080 -880 2 0 {name=p213 sig_type=std_logic lab=Q57b}
C {devices/lab_pin.sym} 6080 -680 2 0 {name=p214 sig_type=std_logic lab=Q67b}
C {devices/lab_pin.sym} 6080 -480 2 0 {name=p215 sig_type=std_logic lab=Q77b}
C {devices/lab_pin.sym} 5460 -480 2 0 {name=p216 sig_type=std_logic lab=Q76b}
C {devices/lab_pin.sym} 5460 -680 2 0 {name=p217 sig_type=std_logic lab=Q66b}
C {devices/lab_pin.sym} 5460 -880 2 0 {name=p218 sig_type=std_logic lab=Q56b}
C {devices/lab_pin.sym} 5460 -1080 2 0 {name=p219 sig_type=std_logic lab=Q46b}
C {devices/lab_pin.sym} 5460 -1280 2 0 {name=p220 sig_type=std_logic lab=Q36b}
C {devices/lab_pin.sym} 5460 -1480 2 0 {name=p221 sig_type=std_logic lab=Q26b}
C {devices/lab_pin.sym} 5460 -1680 2 0 {name=p222 sig_type=std_logic lab=Q16b}
C {devices/lab_pin.sym} 4780 -1680 2 0 {name=p223 sig_type=std_logic lab=Q15b}
C {devices/lab_pin.sym} 4780 -1480 2 0 {name=p224 sig_type=std_logic lab=Q25b}
C {devices/lab_pin.sym} 4780 -1280 2 0 {name=p225 sig_type=std_logic lab=Q35b}
C {devices/lab_pin.sym} 4780 -1080 2 0 {name=p227 sig_type=std_logic lab=Q45b}
C {devices/lab_pin.sym} 4780 -880 2 0 {name=p229 sig_type=std_logic lab=Q55b}
C {devices/lab_pin.sym} 4780 -680 2 0 {name=p231 sig_type=std_logic lab=Q65b}
C {devices/lab_pin.sym} 4780 -480 2 0 {name=p233 sig_type=std_logic lab=Q75b}
C {devices/lab_pin.sym} 4160 -1680 2 0 {name=p235 sig_type=std_logic lab=Q14b}
C {devices/lab_pin.sym} 4160 -1480 2 0 {name=p237 sig_type=std_logic lab=Q24b}
C {devices/lab_pin.sym} 4160 -1280 2 0 {name=p239 sig_type=std_logic lab=Q34b}
C {devices/lab_pin.sym} 4160 -1080 2 0 {name=p241 sig_type=std_logic lab=Q44b}
C {devices/lab_pin.sym} 4160 -880 2 0 {name=p242 sig_type=std_logic lab=Q54b}
C {devices/lab_pin.sym} 4160 -680 2 0 {name=p243 sig_type=std_logic lab=Q64b}
C {devices/lab_pin.sym} 4160 -480 2 0 {name=p244 sig_type=std_logic lab=Q74b}
C {devices/lab_pin.sym} 3500 -480 2 0 {name=p247 sig_type=std_logic lab=Q73b}
C {devices/lab_pin.sym} 3500 -680 2 0 {name=p248 sig_type=std_logic lab=Q63b}
C {devices/lab_pin.sym} 3500 -880 2 0 {name=p249 sig_type=std_logic lab=Q53b}
C {devices/lab_pin.sym} 3500 -1080 2 0 {name=p250 sig_type=std_logic lab=Q43b}
C {devices/lab_pin.sym} 3500 -1280 2 0 {name=p251 sig_type=std_logic lab=Q33b}
C {devices/lab_pin.sym} 3500 -1480 2 0 {name=p252 sig_type=std_logic lab=Q23b}
C {devices/lab_pin.sym} 3500 -1680 2 0 {name=p253 sig_type=std_logic lab=Q13b}
C {devices/lab_pin.sym} 2860 -1680 2 0 {name=p254 sig_type=std_logic lab=Q12b}
C {devices/lab_pin.sym} 2860 -1480 2 0 {name=p255 sig_type=std_logic lab=Q22b}
C {devices/lab_pin.sym} 2860 -1280 2 0 {name=p256 sig_type=std_logic lab=Q32b}
C {devices/lab_pin.sym} 2860 -1080 2 0 {name=p257 sig_type=std_logic lab=Q42b}
C {devices/lab_pin.sym} 2860 -880 2 0 {name=p258 sig_type=std_logic lab=Q52b}
C {devices/lab_pin.sym} 2860 -680 2 0 {name=p259 sig_type=std_logic lab=Q62b}
C {devices/lab_pin.sym} 2860 -480 2 0 {name=p261 sig_type=std_logic lab=Q72b}
C {devices/lab_pin.sym} 2220 -480 2 0 {name=p263 sig_type=std_logic lab=Q71b}
C {devices/lab_pin.sym} 2220 -680 2 0 {name=p265 sig_type=std_logic lab=Q61b}
C {devices/lab_pin.sym} 2220 -880 2 0 {name=p267 sig_type=std_logic lab=Q51b}
C {devices/lab_pin.sym} 2220 -1080 2 0 {name=p269 sig_type=std_logic lab=Q41b}
C {devices/lab_pin.sym} 2220 -1280 2 0 {name=p271 sig_type=std_logic lab=Q31b}
C {devices/lab_pin.sym} 2220 -1480 2 0 {name=p273 sig_type=std_logic lab=Q21b}
C {devices/lab_pin.sym} 2220 -1680 2 0 {name=p275 sig_type=std_logic lab=Q11b}
C {devices/lab_pin.sym} 1560 -1680 2 0 {name=p276 sig_type=std_logic lab=Q10b}
C {devices/lab_pin.sym} 1560 -1480 2 0 {name=p277 sig_type=std_logic lab=Q20b}
C {devices/lab_pin.sym} 1560 -1280 2 0 {name=p278 sig_type=std_logic lab=Q30b}
C {devices/lab_pin.sym} 1560 -1080 2 0 {name=p281 sig_type=std_logic lab=Q40b}
C {devices/lab_pin.sym} 1560 -880 2 0 {name=p282 sig_type=std_logic lab=Q50b}
C {devices/lab_pin.sym} 1560 -680 2 0 {name=p283 sig_type=std_logic lab=Q60b}
C {devices/lab_pin.sym} 1560 -480 2 0 {name=p284 sig_type=std_logic lab=Q70b}
C {devices/gnd.sym} 1790 1660 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 4160 2580 0 1 {name=p285 sig_type=std_logic lab=Dout}
C {sky130_fd_pr/nfet_01v8.sym} 3910 2620 0 0 {name=M49
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3910 2530 0 0 {name=M50
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4050 2620 0 0 {name=M51
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4050 2530 0 0 {name=M52
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4030 2470 1 0 {name=p286 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 4020 2690 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 3820 1500 0 1 {name=p5 sig_type=std_logic lab=Douta}
C {devices/lab_pin.sym} 1210 920 1 0 {name=p287 sig_type=std_logic lab=r0}
C {devices/lab_pin.sym} 1210 960 1 0 {name=p288 sig_type=std_logic lab=r1}
C {devices/lab_pin.sym} 1210 1000 1 0 {name=p289 sig_type=std_logic lab=r2}
C {devices/lab_pin.sym} 1210 1040 1 0 {name=p290 sig_type=std_logic lab=r3}
C {devices/lab_pin.sym} 1210 1080 1 0 {name=p291 sig_type=std_logic lab=r4}
C {devices/lab_pin.sym} 1210 1120 1 0 {name=p292 sig_type=std_logic lab=r5}
C {devices/lab_pin.sym} 1210 1160 1 0 {name=p293 sig_type=std_logic lab=r6}
C {devices/lab_pin.sym} 1210 1190 3 0 {name=p294 sig_type=std_logic lab=r7}
C {devices/lab_pin.sym} 6680 1830 3 1 {name=p295 sig_type=std_logic lab=w0}
C {devices/lab_pin.sym} 6680 1870 3 1 {name=p296 sig_type=std_logic lab=w1}
C {devices/lab_pin.sym} 6680 1910 3 1 {name=p297 sig_type=std_logic lab=w2}
C {devices/lab_pin.sym} 6680 1950 3 1 {name=p298 sig_type=std_logic lab=w3}
C {devices/lab_pin.sym} 6680 1990 3 1 {name=p299 sig_type=std_logic lab=w4}
C {devices/lab_pin.sym} 6680 2030 3 1 {name=p300 sig_type=std_logic lab=w5}
C {devices/lab_pin.sym} 6680 2070 3 1 {name=p301 sig_type=std_logic lab=w6}
C {devices/lab_pin.sym} 6690 2100 1 1 {name=p302 sig_type=std_logic lab=w7}
C {devices/lab_pin.sym} 1140 -1320 3 1 {name=p303 sig_type=std_logic lab=wl0}
C {devices/lab_pin.sym} 1140 -1280 3 1 {name=p304 sig_type=std_logic lab=wl1}
C {devices/lab_pin.sym} 1140 -1240 3 1 {name=p305 sig_type=std_logic lab=wl2}
C {devices/lab_pin.sym} 1140 -1200 3 1 {name=p306 sig_type=std_logic lab=wl3}
C {devices/lab_pin.sym} 1140 -1160 3 1 {name=p307 sig_type=std_logic lab=wl4}
C {devices/lab_pin.sym} 1140 -1120 3 1 {name=p308 sig_type=std_logic lab=wl5}
C {devices/lab_pin.sym} 1140 -1080 3 1 {name=p309 sig_type=std_logic lab=wl6}
C {devices/lab_pin.sym} 1140 -1050 1 1 {name=p310 sig_type=std_logic lab=wl7}
C {devices/lab_pin.sym} 1560 660 0 1 {name=p331 sig_type=std_logic lab=Dout0}
C {devices/lab_pin.sym} 2220 660 0 1 {name=p332 sig_type=std_logic lab=Dout1}
C {devices/lab_pin.sym} 2860 670 0 1 {name=p333 sig_type=std_logic lab=Dout2}
C {devices/lab_pin.sym} 3500 670 0 1 {name=p334 sig_type=std_logic lab=Dout3}
C {devices/lab_pin.sym} 4160 670 0 1 {name=p335 sig_type=std_logic lab=Dout4}
C {devices/lab_pin.sym} 4780 670 0 1 {name=p336 sig_type=std_logic lab=Dout5}
C {devices/lab_pin.sym} 5460 670 0 1 {name=p337 sig_type=std_logic lab=Dout6}
C {devices/lab_pin.sym} 6080 680 0 1 {name=p338 sig_type=std_logic lab=Dout7}
C {sky130_fd_pr/nfet_01v8.sym} 3800 2680 0 0 {name=M53
W=4
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3860 2680 0 1 {name=l7 lab=GND}
C {devices/gnd.sym} 3820 2710 0 1 {name=l8 lab=GND}
C {devices/lab_pin.sym} 3780 2680 2 1 {name=p311 sig_type=std_logic lab=G}
C {devices/lab_pin.sym} 7280 -60 3 1 {name=p312 sig_type=std_logic lab=G}
C {devices/vsource.sym} 7280 -30 0 0 {name=VG value="PULSE(0 1.8 0 .1n .1n 10n 20n 12)" savecurrent=false
lab=vdd}
C {devices/gnd.sym} 7280 0 0 0 {name=l10 lab=GND}
